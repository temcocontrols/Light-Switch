# Keil uVision project rbc_mesh_BLE_Gateway.uvprojx, settings and files
target nRF51422 xxAC (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAB Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_gateway_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\device
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../: main.c nrf_adv_conn.c led_config.c
    ../../../../../bsp/: bsp.c
  group rbc_mesh
    ../../../rbc_mesh/src/: rbc_mesh.c nrf_flash.c mesh_flash.c radio_control.c timer.c timeslot.c trickle.c mesh_gatt.c transport_control.c mesh_aci.c serial_handler_uart.c fifo.c event_handler.c version_handler.c mesh_packet.c bootloader_util.c rand.c handle_storage.c timer_scheduler.c dfu_app.c
  group core
    ./: system_nrf52.c arm_startup_nrf52.s system_nrf51.c arm_startup_nrf51.s
  group nRF_Drivers
    ../../../../../../components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../../components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../../components/drivers_nrf/ppi/: nrf_drv_ppi.c
    ../../../../../../components/drivers_nrf/timer/: nrf_drv_timer.c
    ../../../../../../components/drivers_nrf/hal/: nrf_delay.c nrf_adc.c
    ../../../../../../components/libraries/util/: nrf_assert.c
    ../../../../../../components/drivers_nrf/wdt/: nrf_drv_wdt.c
    ../../../../../../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../../../RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    ../../../../../../components/softdevice/common/softdevice_handler/: softdevice_handler.c
    ../../../../../../components/libraries/button/: app_button.c
    ../../../../../../components/libraries/fifo/: app_fifo.c
    ../../../SDK/10/pwm/: app_pwm.c
    ../../../../../../components/libraries/scheduler/: app_scheduler.c
    ../../../../../../components/libraries/simple_timer/: app_simple_timer.c
    ../../../../../../components/libraries/timer/: app_timer.c
    ../../../../../../components/libraries/util/: app_error.c app_util_platform.c
    ../../../../../../components/libraries/trace/: app_trace.c
  group ble_service
    ../../../../../../components/ble/ble_services/ble_dis/: ble_dis.c
    ../../../../../../components/ble/common/: ble_advdata.c ble_srv_common.c
    ../../../../../../components/ble/ble_services/ble_cts_c/: ble_cts_c.c
    ../../../../../../components/ble/device_manager/: device_manager_peripheral.c
    ../../../../../../components/ble/ble_db_discovery/: ble_db_discovery.c
    ../../../SDK/ble_service/: ble_temperature.c ble_light.c
target nRF51422 xxAC serial (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rbc_gateway_example_serial +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DFU RTT_LOG DEBUG BUTTONS BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL RBC_MESH_DATA_CACHE_ENTRIES=2 RBC_MESH_HANDLE_CACHE_ENTRIES=3
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20002000 size 0x5000
  memory RVCT10: RAM 0x20007000 size 0xffc
target nRF51422 xxAC buttons (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RBC_MESH_DEBUG DEBUG_LOG_RTT BOARD_PCA10028 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BUTTONS DEBUG
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20002000 size 0x6000
target nRF52832 xxAA (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rbc_gateway_example_52 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RBC_MESH_SERIAL MESH_DFU RAM_R1_BASE=0x20003000 NRF_SD_BLE_API_VERSION=3 NORDIC_SDK_VERSION=12 BOARD_PCA10040 NRF52 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain\cmsis\include;..\config;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20003000 size 0x6000
  memory RVCT10: RAM 0x20009000 size 0xffc
target nRF52832 xxAA serial (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example_52 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DFU RBC_MESH_SERIAL RAM_R1_BASE=0x20003000 NRF_SD_BLE_API_VERSION=3 NORDIC_SDK_VERSION=12 BOARD_PCA10040 NRF52 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20003000 size 0x6000
  memory RVCT10: RAM 0x20009000 size 0xffc
target nRF52832 xxAA serial blinky (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example_serial_blinky_PCA10040_nRF52832_xxAA +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DFU RBC_MESH_SERIAL BLINKY RAM_R1_BASE=0x20003000 NRF_SD_BLE_API_VERSION=3 NORDIC_SDK_VERSION=12 BOARD_PCA10040 NRF52 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\..\components\device;..\..\..\..\..\..\components\toolchain\cmsis\include;..\config;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\drivers_nrf\delay
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20003000 size 0x6000
  memory RVCT10: RAM 0x20009000 size 0xffc
target nRF51422 xxAC serial blinky_10031 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example_serial_blinky_PCA10031_nRF51422_xxAC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DFU RTT_LOG DEBUG  BOARD_PCA10031 NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL BLINKY RBC_MESH_DATA_CACHE_ENTRIES=2 RBC_MESH_HANDLE_CACHE_ENTRIES=3
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\SDK\bsp;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\drivers_nrf\hal
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20002000 size 0x5000
  memory RVCT10: RAM 0x20007000 size 0xffc
target nRF51422 xxAC serial blinky_10028 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example_serial_blinky_PCA10028_nRF51422_xxAC +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG  BOARD_LIGHTSWITCH NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT RBC_MESH_SERIAL RBC_MESH_DATA_CACHE_ENTRIES=2 RBC_MESH_HANDLE_CACHE_ENTRIES=3
  c misc: --c99
  c include: ..\include;..\..\..\RTT;..\..\..\..\..\bsp;..\..\..\rbc_mesh;..\..\..\rbc_mesh\include;..\..\..\..\..\..\components\softdevice\s110\headers;..\..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\..\components\toolchain\gcc;..\..\..\..\..\..\components\ble\common;..\..\..\..\..\..\components\drivers_nrf\wdt;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\spi_slave;..\..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\..\components\drivers_nrf\gpiote;..\..\..\..\..\..\components\drivers_nrf\ppi;..\..\..\..\..\..\components\drivers_nrf\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\..\..\..\components\libraries\button;..\..\..\..\..\..\components\libraries\fifo;..\..\..\..\..\..\components\libraries\gpiote;..\..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\..\components\libraries\simple_timer;..\..\..\..\..\..\components\libraries\timer;..\..\..\..\..\..\components\libraries\util;..\..\..\SDK\10\pwm;..\..\..\SDK\ble_service;..\..\..\..\..\..\components\ble\ble_services\ble_dis;..\..\..\..\..\..\components\ble\ble_services\ble_cts_c;..\..\..\..\..\..\components\ble\device_manager\config;..\..\..\..\..\..\components\ble\device_manager;..\..\..\..\..\..\components\ble\ble_db_discovery;..\..\..\..\..\..\components\libraries\trace;..\..\..\..\..\..\components\drivers_nrf\pstorage;..\..\..\..\..\..\components\drivers_nrf\pstorage\config
  memory RVCT4: ROM 0x18000 size 0x18000
  memory RVCT9: RAM 0x20002000 size 0x5000
  memory RVCT10: RAM 0x20007000 size 0xffc
target nRF52832 xxAA buttons (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: rbc_gateway_example_52 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BUTTONS RAM_R1_BASE=0x20003000 NRF_SD_BLE_API_VERSION=3 NORDIC_SDK_VERSION=12 BOARD_PCA10040 NRF52 BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT DEBUG
  c misc: --c99
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x59000
  memory RVCT9: RAM 0x20003000 size 0x6000
  memory RVCT10: RAM 0x20009000 size 0xffc
